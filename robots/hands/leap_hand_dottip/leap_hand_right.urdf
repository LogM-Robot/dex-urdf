Commit message: add leap hand dottip

File: robots/hands/leap_hand_dottip/leap_hand_right.urdf (robot description, URDF)
Before this commit: robot leap_right, 26 links, 25 joints
Joints:
- joint base_joint: origin xyz=0.058 0.038 -0.048 rpy=0 0 0 -> xyz=0.058 0.034 -0.048 rpy=0 0 0
